
# Append our layer's path to override files			   
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"


